require recipes-devtools/go/${PN}.inc
require go-${PV}.inc
