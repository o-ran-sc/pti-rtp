require recipes-devtools/go/go-cross.inc
require go-${PV}.inc
