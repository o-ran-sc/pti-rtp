require recipes-devtools/go/go-cross-canadian.inc
require go-${PV}.inc
