require recipes-devtools/go/go-crosssdk.inc
require go-${PV}.inc
