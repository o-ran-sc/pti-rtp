require go-${PV}.inc
require recipes-devtools/go/go-runtime.inc
