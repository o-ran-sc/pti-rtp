#
# Copyright (C) 2019 Wind River Systems, Inc.
#

do_compile_prepend() {
    unset GOCACHE
}
