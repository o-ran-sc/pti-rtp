#
# Copyright (C) 2019 Wind River Systems, Inc.
#

require kubernetes.inc

PV = "1.14.5+git${SRCREV_kubernetes}"
SRCREV_kubernetes = "0e9fcb426b100a2aea5ed5c25b3d8cfbb01a8acf"
SRC_BRANCH = "release-1.14"
