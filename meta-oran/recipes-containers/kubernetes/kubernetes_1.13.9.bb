#
# Copyright (C) 2019 Wind River Systems, Inc.
#

require kubernetes.inc

PV = "1.13.9+git${SRCREV_kubernetes}"
SRCREV_kubernetes = "3e4f6a92de5f259ef313ad876bb008897f6a98f0"
SRC_BRANCH = "release-1.13"
