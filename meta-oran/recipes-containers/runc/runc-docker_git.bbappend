#
# Copyright (C) 2019 Wind River Systems, Inc.
#

inherit go112
