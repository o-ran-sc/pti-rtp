TARGET_SUPPORTED_KTYPES_append_nxp-lx2xxx = " preempt-rt"
