inherit setuptools

require fault-common.inc

SUBPATH0 = "python-fmclient/fmclient"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1dece7821bf3fd70fe1309eaa37d52a2"
