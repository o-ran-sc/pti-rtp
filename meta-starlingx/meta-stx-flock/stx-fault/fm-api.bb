inherit setuptools

require fault-common.inc

SUBPATH0 = "fm-api"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"
