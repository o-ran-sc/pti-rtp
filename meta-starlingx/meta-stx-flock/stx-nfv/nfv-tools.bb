require nfv-common.inc

SUBPATH0 = "nfv/nfv-tools"

inherit setuptools
