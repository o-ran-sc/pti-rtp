require nfv-common.inc

SUBPATH0 = "nfv/nfv-common"

inherit setuptools
