
DEPENDS += "\
	python-pbr-native \
	"
