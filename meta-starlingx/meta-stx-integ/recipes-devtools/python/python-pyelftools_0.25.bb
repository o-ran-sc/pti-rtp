
DESCRIPTION = "pyelftools library for parsing and analyzing elf files"
LICENSE = "LGPLv2+"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5ce2a2b07fca326bc7c146d10105ccfc"
HOMEPAGE = "https://github.com/eliben/pyelftools"

SRC_URI[sha256sum] = "89c6da6f56280c37a5ff33468591ba9a124e17d71fe42de971818cbff46c1b24"

PYPI_PACKAGE = "pyelftools"
inherit pypi setuptools
