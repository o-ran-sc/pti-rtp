
DESCRIPTION = "Urwid is a console user interface library for Python."
LICENSE = "LGPLv2+"
LIC_FILES_CHKSUM = "file://COPYING;md5=243b725d71bb5df4a1e5920b344b86ad"
HOMEPAGE = "http://urwid.org/"

SRC_URI[sha256sum] = "644d3e3900867161a2fc9287a9762753d66bd194754679adb26aede559bcccbc"


PYPI_PACKAGE = "urwid"
inherit pypi setuptools
