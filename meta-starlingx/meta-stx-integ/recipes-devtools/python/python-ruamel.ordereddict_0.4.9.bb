
DESCRIPTION = "The ordereddict module in short"
HOMEPAGE = "https://pypi.org/project/ruamel.ordereddict/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=0caf06c5d151e57e100341eb28dcb6f5"

SRC_URI[md5sum] = "d160714193a0ec470cc26f614b1aa0e7"
SRC_URI[sha256sum] = "7058c470f131487a3039fb9536dda9dd17004a7581bdeeafa836269a36a2b3f6"

inherit setuptools pypi
