
DESCRIPTION = "HPE 3PAR HTTP REST Client"
HOMEPAGE = "https://pythonhosted.org/python-3parclient/"
SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=c6f4d3b3208673edc0228bbc3ad053cc"

SRC_URI[md5sum] = "845e688b5607a71fc307e8371daf5d40"
SRC_URI[sha256sum] = "fcd1c5c7d9356f4244a6c0b2b6dd6c64366399642c348b02999ea8fbf79e3a8d"

PYPI_PACKAGE = "python-3parclient"
inherit setuptools pypi
