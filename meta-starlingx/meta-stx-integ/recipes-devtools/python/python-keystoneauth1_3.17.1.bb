
inherit setuptools
require python-keystoneauth1.inc
