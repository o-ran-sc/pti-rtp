

PV = "3.19.0+git${SRCPV}"
SRCREV = "83359fbe4fd7e5850abd45a467bf197c284519b1"

SRC_URI = " \
        git://github.com/openstack/python-openstackclient.git;branch=stable/stein \
	"
