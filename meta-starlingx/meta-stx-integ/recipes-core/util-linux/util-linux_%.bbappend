
# Increase su.util-linux update-alternative priortiy

ALTERNATIVE_PRIORITY[su] = "300"
