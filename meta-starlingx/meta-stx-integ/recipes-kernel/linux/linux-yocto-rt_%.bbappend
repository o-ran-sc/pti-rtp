
require linux-yocto-stx.inc
