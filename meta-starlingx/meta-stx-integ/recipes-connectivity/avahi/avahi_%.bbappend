RRECOMMENDS_${PN}_remove_libc-glibc = "libnss-mdns"
RRECOMMENDS_${PN}-daemon_remove_libc-glibc = "libnss-mdns"
