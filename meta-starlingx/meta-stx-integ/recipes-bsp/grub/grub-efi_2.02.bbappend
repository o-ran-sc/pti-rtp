
TRANSFORM_NAME = "s,grub,grub2,"
EXTRA_OECONF += "--program-transform-name=${TRANSFORM_NAME} \
                "
