
inherit openssl10
DEPENDS_append = " openssl"
