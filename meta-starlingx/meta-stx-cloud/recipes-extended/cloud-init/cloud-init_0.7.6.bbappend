
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://cloud-init-interactive-parted.patch \
	"
