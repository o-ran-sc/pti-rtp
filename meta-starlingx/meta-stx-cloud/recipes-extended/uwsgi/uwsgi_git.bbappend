
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-pragma-ignore-cast-type-errors-with-gcc-8.3.patch"
