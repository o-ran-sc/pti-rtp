
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://eventlet/0001-CGTS-2869-close-connection-on-HTTP-413-Request-Entit.patch"
