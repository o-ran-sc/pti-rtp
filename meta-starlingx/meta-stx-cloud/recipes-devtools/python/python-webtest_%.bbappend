
RDEPENDS_${PN}_append = " python-waitress"
