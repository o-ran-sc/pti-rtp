
PV = "3.33.0+git${SRCPV}"
SRCREV = "58fb709f58bd031c5114d9b6fe2e0926175b87b6"
SRC_URI = "git://github.com/openstack/oslo.utils.git;branch=stable/queens"

