
RDEPENDS_${PN}_append = " \
	python-mimeparse \
	python-traceback2 \
	python-unittest2 \
	"
