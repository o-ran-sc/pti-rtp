
RDEPENDS_${PN}_append = " python-paramiko"
