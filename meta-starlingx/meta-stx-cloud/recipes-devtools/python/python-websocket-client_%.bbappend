
RDEPENDS_${PN}_append = " \
	${PYTHON_PN}-backports-ssl \
	"
