
RDEPENDS_${PN}_append = " python-munch"
RDEPENDS_${PN}_append = " python2-os-service-types"
