
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://requests/0001-close-connection-on-HTTP-413-Request-Entit.patch"
