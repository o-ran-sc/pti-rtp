
RDEPENDS_${PN} += "python-importlib-metadata"
