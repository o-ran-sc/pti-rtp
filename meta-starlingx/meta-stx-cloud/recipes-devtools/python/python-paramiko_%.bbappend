
RDEPENDS_${PN}_append = " \
	python-bcrypt \
	python-pynacl \
	"
