
RDEPENDS_${PN} += " bash"
PV = "0.25.0+git${SRCPV}"
SRCREV="9cd0ef2ac5b8cc90df344f69edc8ac68224f292e"

