
RDEPENDS_${PN}_append = " python-pycparser"
