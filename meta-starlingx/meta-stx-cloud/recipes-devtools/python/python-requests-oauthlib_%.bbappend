
RDEPENDS_${PN}_append = " \
	python-oauthlib \
	"
