
RDEPENDS_${PN}_append = " \
	python-numpy \
	"
