
inherit openssl10
